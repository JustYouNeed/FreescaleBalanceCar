# Keil uVision project FreescaleCar.uvprojx, settings and files
target FreescaleCar (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FreescaleCar +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\APP\inc;..\BSP\inc;..\CORE;..\LIB\inc;..\USER;..\MPU\inc;..\GUI_DRV\interface;..\GUI_APP\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group USER
    ./: main.c FreescaleCar.c
  group CORE
    ../CORE/: startup_SKEAZ1284.s system_SKEAZ1284.c
  group LIB
    ../LIB/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_spi.c KEA128_systick.c KEA128_uart.c misc.c drv_adc.c drv_pit.c
  group BSP
    ../BSP/src/: bsp.c bsp_encoder.c bsp_key.c bsp_led.c bsp_motor.c bsp_oled.c bsp_sensor.c bsp_switch.c bsp_timer.c bsp_uart.c bsp_i2c.c bsp_mpu.c
  group MPU
    ../MPU/src/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group APP
    ../APP/src/: app_debug.c app_filter.c app_pid.c app_sort.c
  group GUI_DRV
    ../GUI_DRV/src/: button.c font.c gui_basic.c gui_menu.c lcmdrv.c messagebox.c scrollbar.c text.c windows.c
  group GUI_APP
    ../GUI_APP/src/: calibration.c display.c gui_setting.c main_ui.c menu.c para_show.c pid_set.c
